# Keil uVision project _slm-101s.uvproj, settings and files
target _Wess (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: _slm_101s.omf
  c flags: Optimize=8 SizeSpeed=1
  c include: .\_src\b0_comm;.\_Wess\_compiler;.\_Wess\app;.\_Wess\bsp;.\_Wess\menu;.\_Wess\disp;.\_Wess\measure;.\_Wess\font;.\_Wess\screen
  group b0_bsp
    ./_Wess/_compiler/: STARTUP.A51 L51_BANK.A51
    ./_Wess/bsp/: lcd_main.c lcd_data.c
    ./_Wess/app/: isr_main.c
  group b1_app
    ./_Wess/bsp/: flash_main.c spi_main.c gpio_main.c dac_main.c bsp_main.c adc_main.c tmr_main.c bsp_rest.c
    ./_Wess/app/: dly_main.c crc_main.c prtc_main.c modbus_main.c mem_main.c main.c app_main.c
    ./_Wess/font/: font_def.c
    ./_Wess/disp/: disp_main.c
    ./_Wess/measure/: measure_main.c measure_analyze.c measure_temperature.c
  group b2_disp
    ./_Wess/screen/: screen_main.c
    ./_Wess/bsp/: btn_main.c pcd_main.c rly_main.c uart_main.c rtc_ds1302.c rf_main.c pwm_main.c
    ./_Wess/disp/: disp_menu.c disp_string.c
    ./_Wess/menu/: menu_pass.c menu_main.c menu_data.c menu_box.c menu_engineer.c menu_test.c
    ./_Wess/app/: data.main.c
  group b3_menu
    ./_Wess/menu/: menu_quick.c menu_output.c menu_measure.c menu_system.c menu_factory.c
